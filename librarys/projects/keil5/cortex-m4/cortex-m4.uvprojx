# Keil uVision project cortex-m4.uvprojx, settings and files
target cortex-m4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cortex-m4 (library)
  AfterMake: ..\..\..\sdk\after.bat .\Objects\cortex-m4.lib ..\..\..\code\portable\cortex-m4\inc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\defs;..\..\..\code\portable\cortex-m4\inc;..\..\..\code\portable\cortex-m4\board\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group task
    ../../../code/portable/cortex-m4/src/: exception_handler.c ptask.c pexclusive.c pservice.c
  group storage
    ../../../code/portable/cortex-m4/src/: pmmap.c pmpu.c
