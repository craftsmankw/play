# Keil uVision project play.uvprojx, settings and files
target play (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: play
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PRNAME="PLAY"
  c include: ..\..\..\source\portable\board\inc;..\..\..\librarys\sdk\inc;..\..\..\defs;..\..\..\source\kernel\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\Objects\play.sct
  group kernel
    ../../../source/kernel/: stack.c play.c service.c task_scheduler.c tasks.c heap_5.c mpu_cfg.c
  group librarys
    ../../../librarys/sdk/: cortex-m4.lib
  group dev
    ../../../source/dev/: dev.c
  group portable
    ../../../source/portable/board/: system_stm32f4xx.c
    ../../../source/portable/board/arm/: startup_stm32f401xe.s
